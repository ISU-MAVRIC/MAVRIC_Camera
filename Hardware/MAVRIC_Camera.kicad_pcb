# Repository ISU-MAVRIC/MAVRIC_Camera

File README.md:

MAVRIC_Camera
=============

Hardware and firmware for MAVRIC's camera system

Hardware design files use the [Aerodyne Labs KiCad library](https://github.com/aerodynelabs/kicadlib)

Based off the [Fubarino Mini](http://fubarino.org/mini/)

## KiCad design Hardware/MAVRIC_Camera.kicad_pcb

Parts:
C1, C2, C15, C16, C18, C19, C21, C22, C23, C24, C25: 22uF; Voltage 25V
C3, C17, C20: C
C4: 10nF
C5, C6, C10, C12, C13, C14: 0.1uF
C7: 2.2nF
C8, C9: 18pF
C11: 10uF
D1, D2: LED
J1: MASTER
J2: CAMERA
J3: SERVO
J4: ICSP-PIC
J5: USB_MINI
L1: 33uH; MFR Part No SRN4018-330M
L2, L3: 22uH
R1, R3, R4, R9, R11, R12, R14, R15, R16, R17, R18: R
R2, R5, R6, R7, R8, R10, R13: 10k
SW1: PRGM
SW2: RESET
U1: PIC32MX250F128D
U2: MPU9150
U3, U4, U5: AOZ1031
X1: 8MHz

Connections:
+3.3V: C1.1, C2.1, C4.1, C5.1, C12.1, C13.1, C14.1, J4.2 (Vdd), L1.2, R5.2, R6.2, R7.2, R8.2, R14.2, R17.1, U1.10 (VUSB), U1.17 (AVdd), U1.28 (Vdd), U1.40 (Vdd), U2.3 (Vdd), U2.8 (VLogic), U2.13 (Vdd)
+BATT: C15.1, C19.1, C23.1, C24.1, C25.1, J1.4, J1.5, R13.2, U3.2 (VIn), U4.2 (VIn), U5.2 (VIn)
/CamEn: R10.2, U1.27 (RC2), U4.6 (En)
/CamLx: L2.1, U4.7 (L), U4.8 (L)
/CamPwr: C16.1, C18.1, J2.4, L2.2, R9.2
/D+: J5.3, U1.8 (RB10)
/D-: J5.2, U1.9 (RB11)
/LED: R18.1, U1.41 (RB5)
/Lx: L1.1, U5.7 (L), U5.8 (L)
/OSC1: C8.1, U1.30 (OSC1), X1.1
/OSC2: C9.1, U1.31 (OSC2), X1.2
/PGC: J4.5 (PGC), U1.22 (RB1)
/PGD: J4.4 (PGD), U1.21 (RB0)
/PRGM: R7.1, SW1.2, U1.32 (RA8)
/Pan: J3.1, U1.34 (RA4)
/SCL: R5.1, U1.24 (RB3), U2.23 (SCL)
/SDA: R6.1, U1.23 (RB2), U2.24 (SDA)
/ServoEn: R2.2, U1.36 (RC3), U3.6 (En)
/SevLx: L3.1, U3.7 (L), U3.8 (L)
/SevPwr: C21.1, C22.1, J3.4, J3.5, L3.2, R1.2
/Tilt: J3.3, U1.35 (RA9)
/U1Rx: J1.3, U1.26 (RC1)
/U1Tx: J1.6, U1.25 (RC0)
/U2Rx: J2.2, U1.43 (RB7)
/U2Tx: J2.1, U1.44 (RB8)
/VBus: J5.1, U1.42 (VBus)
/VCap: C10.1, C11.1, U1.7 (VCap)
/Video: J1.2, J2.6
/~MCLR: J4.1 (MCLR), R8.1, SW2.2, U1.18 (~MCLR)
AGND: J1.1, J2.7
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, D1.2, D2.2, J1.7, J1.8, J2.3, J2.5, J2.9, J3.2, J3.6, J3.7, J3.8, J4.3 (Vss), J5.5, R2.1, R4.1, R10.1, R12.1, R16.1, SW1.1, SW2.1, U1.6 (Vss), U1.16 (AVss), U1.29 (Vss), U1.39 (Vss), U2.1 (ClkIn), U2.9 (AD0), U2.11 (FSync), U2.18 (Vss), U3.1 (PGnd), U3.3 (AGnd), U4.1 (PGnd), U4.3 (AGnd), U5.1 (PGnd), U5.3 (AGnd)
unnamed: C7.1, U2.20 (CPOut)
unnamed: C6.1, U2.10 (RegOut)
unnamed: R3.2, U3.5 (Comp)
unnamed: C3.1, R3.1
unnamed: R1.1, R4.2, U3.4 (FB)
unnamed: D1.1, R17.2
unnamed: R13.1, U5.6 (En)
unnamed: D2.1, R18.2
unnamed: R11.2, U4.5 (Comp)
unnamed: C17.1, R11.1
unnamed: R9.1, R12.2, U4.4 (FB)
unnamed: R14.1, R16.2, U5.4 (FB)
unnamed: R15.2, U5.5 (Comp)
unnamed: C20.1, R15.1

Board: 2 copper layers, 65.0 x 50.0 mm, 65 parts (0 on the bottom side), 45 nets.

Other parts of the board:
MECH-HOLE220-1, MECH-HOLE220-2, MECH-HOLE220-3, MECH-HOLE220-4: VAL**; MECH-HOLE220

## Commit log

2013-09-02 Initial hardware sizing
2013-09-02 Add Dynamixel servo interface
2013-09-02 Add servo power supply.
2013-09-04 Remove dynamixel interface, Add standard PWM
2013-09-07 Finish schematic
2013-09-09 Power systems layout
2013-09-10 Reload packages for 3d models
2013-09-11 New pinout. Update component layout
2013-09-11 Completed PCB Design!
2013-09-13 Rough firmware start
2013-09-15 Implement additional methods in SonyFCB class.
2013-09-15 Implement servo control. Untested
2013-09-15 Implement position command parsing. Untested
2013-09-18 Fix updateServo output
2013-09-19 Documentation/formatting
2013-09-20 Command parsing functional
    Serial1 commands were preventing regular serial communication (via USB)
    from functioning.
2013-09-27 Servo position values
    Positioning of servos now correct (see specification in comments).
2013-09-28 Add voltage divider values
2013-09-28 Add compensation resistor values
2013-10-17 Update to Fubarino
2014-12-11 Reversed camera connector on schematic
